File: PCBs/Upper Panel/Euclid_Upper_panel.brd (EAGLE design)
At the start: 0 parts

Commit message: New version with sample file support
Other:
- board outline added: 182.4 x 127.2 mm
