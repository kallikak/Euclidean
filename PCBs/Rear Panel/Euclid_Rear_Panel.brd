File: PCBs/Rear Panel/Euclid_Rear_Panel.brd (EAGLE design)
At the start: 173 x 41.1 mm, 0 parts

Commit message: New version with sample file support
Other:
- outline, holes or cut-outs redrawn
